## config/boards/shields/silakka54/Kconfig.defconfig
```kconfig
if SHIELD_SILAKKA54_LEFT || SHIELD_SILAKKA54_RIGHT

config ZMK_KEYBOARD_NAME
    default "Silakka54"

endif
```
